# Keil uVision project TM1638.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: TM1638 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c TM1638_drive.c delay.c
